# IAR project RZ_A1L_DMAC.ewp, settings and files
configuration Debug-from-RAM (ARM, debug)
  General.OGChipSelectEditMenu: R7S721020 Renesas R7S721020
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 52
  General.FPU2: 3
  ICCARM.CCIncludePath2: inc; inc\iodefines; inc\iobitmasks; qspi_controller_driver\inc; compiler_specific\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: compiler_specific\inc
  OBJCOPY.OOCOutputFile: RZ_A1H_DMAC.srec
  ILINK.IlinkOutputFile: RZ_A1H_DMAC-RAM.out
  ILINK.IlinkIcfFile: compiler_specific\IAR-RAM-APP_RZL.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug-DUAL-QSPI (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG
  ILINK.IlinkOutputFile: RZ_A1H_DMAC-QSPI.out
  ILINK.IlinkIcfFile: compiler_specific\IAR-QSPI-APP_RZL.icf
configuration Debug-SINGLE-QSPI (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG
  OBJCOPY.OOCOutputFile: RZ_A1L_DMAC.srec
  ILINK.IlinkOutputFile: RZ_A1H_DMAC-QSPI.out
  ILINK.IlinkIcfFile: compiler_specific\IAR-QSPI-APP_RZL.icf
  group compiler_specific
    compiler_specific/: IAR-QSPI-APP_RZL.icf IAR-RAM-APP_RZL.icf
  group compiler_specific/asm
    compiler_specific/asm/: access_iar.s application_signature_iar.s cmain_iar.s init_ttb_iar.s irqfiq_handler_iar.s l1_cache_iar_asm.s reset_handler_iar.s start_iar.s
  group compiler_specific/inc
    compiler_specific/inc/: assembler_macros.h compiler_settings.h gnu_io.h l1_cache.h l2_cache.h l2_cache_pl310.h resetprg.h
  group compiler_specific/src
    compiler_specific/src/: access.c copy_section_to_ram.c gnu_io.c l1_cache.c l2_cache.c l2_cache_pl310.c low_level_init_iar.c
  group inc
    inc/: ascii.h bsc.h bsc_userdef.h dev_drv.h devdrv_common.h devdrv_intc.h devdrv_riic.h devdrv_scif_uart.h iodefine.h lcd_pmod.h logo.h main.h peripheral_early_init.h r_typedefs.h rspi.h rza_io_regrw.h sample_adc.h sample_led.h sample_riic_rza1h_rsk.h sio_char.h stb_init.h switches.h typedefine.h
  group inc/iobitmasks
    inc/iobitmasks/: adc_iobitmask.h bsc_iobitmask.h cpg_iobitmask.h dmac_iobitmask.h gpio_iobitmask.h intc_iobitmask.h mtu2_iobitmask.h ostm_iobitmask.h riic_iobitmask.h rspi_iobitmask.h scif_iobitmask.h spibsc_iobitmask.h usb_iobitmask.h
  group inc/iodefines
    inc/iodefines/: adc_iodefine.h bsc_iodefine.h ceu_iodefine.h cpg_iodefine.h disc_iodefine.h dmac_iodefine.h dvdec_iodefine.h ether_iodefine.h flctl_iodefine.h gpio_iodefine.h ieb_iodefine.h inb_iodefine.h intc_iodefine.h irda_iodefine.h jcu_iodefine.h l2c_iodefine.h lin_iodefine.h lvds_iodefine.h mlb_iodefine.h mmc_iodefine.h mtu2_iodefine.h ostm_iodefine.h pfc_iodefine.h pfv_iodefine.h pwm_iodefine.h riic_iodefine.h romdec_iodefine.h rscan0_iodefine.h rspi_iodefine.h rtc_iodefine.h scif_iodefine.h scim_iodefine.h scux_iodefine.h sdg_iodefine.h spdif_iodefine.h spibsc_iodefine.h ssif_iodefine.h usb20_iodefine.h vdc5_iodefine.h wdt_iodefine.h
  group src
    src/: ascii.c bsc.c bsc_userdef.c intc.c intc_handler.c intc_userdef.c lcd_pmod.c logo.c main.c peripheral_early_init.c riic.c riic_userdef.c rspi.c rspi_user.c rza_io_regrw.c sample_led.c sample_riic_rza1h_rsk.c scif_uart.c scif_uart_userdef.c sio_char.c siorw.c stb_init.c switches.c
