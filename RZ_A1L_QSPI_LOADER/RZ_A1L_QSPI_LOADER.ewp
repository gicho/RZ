# IAR project RZ_A1L_QSPI_LOADER.ewp, settings and files
configuration Dual_QSPI_Debug (ARM, debug)
  General.OGChipSelectEditMenu: R7S721020 Renesas R7S721020
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 52
  General.FPU2: 3
  ICCARM.CCDefines: DUAL_QSPI_BOARD; DEBUG
  ICCARM.CCIncludePath2: inc; inc\iodefines; inc\iobitmasks; qspi_controller_driver\inc; ..\toolchain_support; ..\architecture_support\CA9\inc; ..\chip_support\inc; ..\board_support\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: RZ_A1H_QSPI_LOADER.srec
  ILINK.IlinkOutputFile: RZ_A1H_QSPI_LOADER.out
  ILINK.IlinkIcfFile: linker_script\RZA1L_IAR_QSPI_BL.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Single_QSPI_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: R7S721001 Renesas R7S721001
  ICCARM.CCDefines: SINGLE_QSPI_BOARD; DEBUG
  ICCARM.CCIncludePath2: inc; inc\iodefines; inc\iobitmasks; qspi_controller_driver\inc; ..\toolchain_support; ..\architecture_support\CA9\inc; ..\chip_support\inc; ..\board_support\Stream_it
  group common/toolchain_support
    ../toolchain_support/: assembler_macros.h compiler_settings.h
  group inc
    inc/: iodefine.h qspi_setup.h rza_io_regrw.h
  group inc/iobitmasks
    inc/iobitmasks/: adc_iobitmask.h bsc_iobitmask.h cpg_iobitmask.h dmac_iobitmask.h gpio_iobitmask.h intc_iobitmask.h mtu2_iobitmask.h ostm_iobitmask.h riic_iobitmask.h rspi_iobitmask.h scif_iobitmask.h spibsc_iobitmask.h usb_iobitmask.h
  group inc/iodefines
    inc/iodefines/: adc_iodefine.h bsc_iodefine.h ceu_iodefine.h cpg_iodefine.h disc_iodefine.h dmac_iodefine.h dvdec_iodefine.h ether_iodefine.h flctl_iodefine.h gpio_iodefine.h ieb_iodefine.h inb_iodefine.h intc_iodefine.h irda_iodefine.h jcu_iodefine.h l2c_iodefine.h lin_iodefine.h lvds_iodefine.h mlb_iodefine.h mmc_iodefine.h mtu2_iodefine.h ostm_iodefine.h pfc_iodefine.h pfv_iodefine.h pwm_iodefine.h riic_iodefine.h romdec_iodefine.h rscan0_iodefine.h rspi_iodefine.h rtc_iodefine.h scif_iodefine.h scim_iodefine.h scux_iodefine.h sdg_iodefine.h spdif_iodefine.h spibsc_iodefine.h ssif_iodefine.h uahv_iodefine.h usb20_iodefine.h vdc5_iodefine.h wdt_iodefine.h
  group linker_script
    linker_script/: RZA1L_IAR_QSPI_BL.icf
  group qspi_controller_driver/inc
    qspi_controller_driver/inc/: flash_type_definitions.h qspi_controller.h
  group qspi_controller_driver/src
    qspi_controller_driver/src/: external_address_mode.c qspi_controller.c spi_mode.c
  group src
    src/: main.c qspi_change_config.c rza_io_regrw.c
  group startup
    startup/: cmain_iar.s low_level_init_iar.c reset_handler_iar.s start_iar.s
