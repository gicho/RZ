<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Flashloader_RZ_RSK_SerialFlash.ewp</path>
  </project>
  <batchBuild/>
</workspace>
