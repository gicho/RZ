# IAR project Flashloader_RZ_RSK_SerialFlash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: R7S721001 Renesas R7S721001
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 52
  General.FPU2: 3
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\src\flashloader\framework2\; 
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Flashloader_RZ_RSK_SerialFlash.srec
  postbuild: cmd /c "copy RZ_RSK_SerialFlash\Exe\RZ_RSK_SerialFlash.out ..\flash_loader\RZ_RSK_SerialFlash.out"
  ILINK.IlinkOutputFile: RZ_RSK_SerialFlash.out
  ILINK.IlinkIcfFile: RZ_RSK_SerialFlash.icf
  ILINK.IlinkProgramEntryLabel: FlashInitEntry
  group (top)
    ./: FlashRTKRZA1H_SerialFlash.c readme.txt
  group Framework
    $EW_DIR$/arm/src/flashloader/framework2/: flash_loader.c flash_loader_asm.s
  group Others
    ./: RZ_RSK_SerialFlash.icf
    ../: RZ_RSK_SerialFlash.mac
