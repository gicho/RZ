# IAR project RZ_A1H_DMAC.ewp, settings and files
configuration Debug-from-RAM (ARM, debug)
  General.OGChipSelectEditMenu: R7S721001 Renesas R7S721001
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 52
  General.FPU2: 3
  ICCARM.CCIncludePath2: ..\toolchain_support; ..\architecture_support\CA9\inc; ..\chip_support\RZA_RZM\inc; inc; inc\iodefines; inc\iobitmasks; qspi_controller_driver\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: compiler_specific\inc
  OBJCOPY.OOCOutputFile: RZ_A1H_DMAC.srec
  ILINK.IlinkOutputFile: RZ_A1H_DMAC-RAM.out
  ILINK.IlinkIcfFile: linker_script\RZA_IAR_RAM_APP.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug-DUAL-QSPI (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG
  ILINK.IlinkOutputFile: RZ_A1H_DMAC-QSPI.out
  ILINK.IlinkIcfFile: linker_script\RZA_IAR_QSPI_APP.icf
configuration Debug-SINGLE-QSPI (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG
  ILINK.IlinkOutputFile: RZ_A1H_DMAC-QSPI.out
  ILINK.IlinkIcfFile: linker_script\RZA_IAR_QSPI_APP.icf
  group common/architecture_support/CA9/asm/iar
    ../architecture_support/CA9/asm/iar/: cp15_access_iar_asm.s l1_cache_iar_asm.s mutex_iar.s semaphore_iar.s
  group common/architecture_support/CA9/inc
    ../architecture_support/CA9/inc/: cp15_access.h l1_cache.h mutex.h semaphore.h
  group common/architecture_support/CA9/src
    ../architecture_support/CA9/src/: cp15_access.c l1_cache.c
  group common/chip_support/RZA_RZM/asm/iar
    ../chip_support/RZA_RZM/asm/iar/: init_ttb_iar.s irqfiq_handler_iar.s
  group common/chip_support/RZA_RZM/inc
    ../chip_support/RZA_RZM/inc/: l2_cache.h l2_cache_pl310.h
  group common/chip_support/RZA_RZM/src
    ../chip_support/RZA_RZM/src/: copy_section_to_ram.c l2_cache.c l2_cache_pl310.c
  group common/toolchain_support
    ../toolchain_support/: compiler_settings.h
  group inc
    inc/: ascii.h dev_drv.h devdrv_common.h devdrv_intc.h devdrv_riic.h devdrv_scif_uart.h iodefine.h lcd_pmod.h logo.h peripheral_early_init.h r_typedefs.h rsk.h rspi.h rza_io_regrw.h sample_adc.h sample_led.h sample_riic_rza1h_rsk.h sio_char.h stb_init.h switches.h typedefine.h
  group inc/iobitmasks
    inc/iobitmasks/: adc_iobitmask.h bsc_iobitmask.h cpg_iobitmask.h dmac_iobitmask.h gpio_iobitmask.h intc_iobitmask.h mtu2_iobitmask.h ostm_iobitmask.h riic_iobitmask.h rspi_iobitmask.h scif_iobitmask.h spibsc_iobitmask.h usb_iobitmask.h
  group inc/iodefines
    inc/iodefines/: adc_iodefine.h bsc_iodefine.h ceu_iodefine.h cpg_iodefine.h disc_iodefine.h dmac_iodefine.h dvdec_iodefine.h ether_iodefine.h flctl_iodefine.h gpio_iodefine.h ieb_iodefine.h inb_iodefine.h intc_iodefine.h irda_iodefine.h jcu_iodefine.h l2c_iodefine.h lin_iodefine.h lvds_iodefine.h mlb_iodefine.h mmc_iodefine.h mtu2_iodefine.h ostm_iodefine.h pfc_iodefine.h pfv_iodefine.h pwm_iodefine.h riic_iodefine.h romdec_iodefine.h rscan0_iodefine.h rspi_iodefine.h rtc_iodefine.h scif_iodefine.h scim_iodefine.h scux_iodefine.h sdg_iodefine.h spdif_iodefine.h spibsc_iodefine.h ssif_iodefine.h usb20_iodefine.h vdc5_iodefine.h wdt_iodefine.h
  group linker_script
    linker_script/: RZA_IAR_QSPI_APP.icf RZA_IAR_RAM_APP.icf
  group scripts
    scripts/: reset.mac RZ_RSK_QSPI_init.mac RZ_RSK_RAM_init.mac
  group src
    src/: ascii.c dma_tests.c intc.c intc_handler.c intc_userdef.c lcd_pmod.c logo.c main.c riic.c riic_rskrza1h.c riic_userdef.c rspi.c rspi_user.c rza_io_regrw.c sample_led.c scif_uart.c scif_uart_userdef.c sio_char.c siorw.c switches.c
  group startup
    startup/: cmain_iar.s low_level_init_iar.c reset_handler_iar.s start_iar.s
