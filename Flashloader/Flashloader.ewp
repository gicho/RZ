# IAR project Flashloader.ewp, settings and files
configuration Flashloader (ARM, debug)
  General.OGChipSelectEditMenu: R7S721001 Renesas R7S721001
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 52
  General.FPU2: 3
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: Flashloader.out
  ILINK.IlinkIcfFile: Flashloader\Flashloader_SerialFlash.icf
  ILINK.IlinkProgramEntryLabel: FlashInitEntry
  group (top)
    Flashloader/: flash_loader.c flash_loader_asm.s FlashRTKRZA1H_SerialFlash.c
