# IAR project Flashloader_RZL.ewp, settings and files
configuration Flashloader (ARM, debug)
  General.OGChipSelectEditMenu: R7S721020 Renesas R7S721020
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 52
  General.FPU2: 3
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Flashloader_RZL.srec
  ILINK.IlinkOutputFile: Flashloader.out
  ILINK.IlinkIcfFile: Flashloader\Flashloader_SerialFlash_RZL.icf
  ILINK.IlinkProgramEntryLabel: FlashInitEntry
  group (top)
    Flashloader/: flash_loader.c flash_loader_asm.s Flashloader_SerialFlash_RZL.icf FlashRTKRZA1H_SerialFlash.c
