<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\RZ_A1H_DMAC\RZ_A1H_DMAC.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\RZ_A1H_QSPI_LOADER\RZ_A1H_QSPI_LOADER.ewp</path>
  </project>
  <batchBuild/>
</workspace>


